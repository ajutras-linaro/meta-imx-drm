# change http plugins as iMX8/gst 1.12
RDEPS_VIDEO_remove_imx8mqevk = " gstreamer1.0-plugins-good-souphttpsrc"
RDEPS_VIDEO_append_imx8mqevk = " gstreamer1.0-plugins-good-soup"
