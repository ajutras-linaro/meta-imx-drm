# WPE Webkit requires opus & faad
PACKAGECONFIG_append_mx8 = " opus-parse faad"
