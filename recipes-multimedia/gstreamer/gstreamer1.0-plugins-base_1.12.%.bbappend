# WPE Webkit requires opus
PACKAGECONFIG_append_imx8mqevk = " opus"
